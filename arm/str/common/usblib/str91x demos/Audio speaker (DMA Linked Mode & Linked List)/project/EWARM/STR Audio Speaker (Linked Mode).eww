<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STR Audio Speaker (Linked Mode).ewp</path>
  </project>
  <batchBuild/>
</workspace>


