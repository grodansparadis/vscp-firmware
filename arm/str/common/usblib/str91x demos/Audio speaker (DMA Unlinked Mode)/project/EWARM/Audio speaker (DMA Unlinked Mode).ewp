# IAR project Audio speaker (DMA Unlinked Mode).ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: STR912 ST STR912
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\library\inc; ..\..\..\..\stdlib\str91x\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
  group (top)
    ./: 91x_init.s 91x_vect.s
  group Application files
    ../../source/: 91x_it.c hw_config.c main.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group library
    ../../../../library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group stdlib/str91x
    ../../../../stdlib/str91x/src/: 91x_ahbapb.c 91x_dma.c 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_vic.c
