# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: STR730 ST STR730
  ICCARM.CCIncludePath2: ..\; ..\..\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    ../: 73x_it.c main.c
  group library
    ../../Library/src/: 73x_adc.c 73x_bspi.c 73x_can.c 73x_cfg.c 73x_cmu.c 73x_dma.c 73x_eic.c 73x_flash.c 73x_gpio.c 73x_i2c.c 73x_lib.c 73x_prccu.c 73x_pwm.c 73x_rtc.c 73x_tb.c 73x_tim.c 73x_uart.c 73x_wdg.c 73x_wiu.c 73x_wut.c
  group startup
    ./: 73x_init.s 73x_vect.s
