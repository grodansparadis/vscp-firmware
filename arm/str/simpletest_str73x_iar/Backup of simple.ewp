# IAR project Backup of simple.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: STR730 ST STR730
  ICCARM.CCIncludePath2: D:\dev\vscp\firmware\ARM\common\str\STR73xLibrary\include; D:\dev\vscp\firmware\ARM\str\simpletest_str73x_iar; D:\dev\vscp\firmware\ARM\common\str
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: linker\lnkarm_flash.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: 73x_conf.h 73x_it.c main.c Readme.txt
    ../../common/str/: 73x_lcd.c 73x_lcd.h
  group Startup
    Startup/: 73x_init.s 73x_vect.s
  group STR73x_Library
    ../../common/str/STR73xLibrary/source/: 73x_adc.c 73x_cfg.c 73x_cmu.c 73x_eic.c 73x_gpio.c 73x_lib.c
