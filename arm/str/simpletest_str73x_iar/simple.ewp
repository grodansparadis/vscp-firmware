# IAR project simple.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR730 ST STR730
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: D:\development\m2m\firmware\arm\str\common\str73x_lib\include; D:\development\m2m\firmware\ARM\str\simpletest_str73x_iar; D:\development\m2m\firmware\ARM\str\common\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: simple.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ./: 73x_conf.h 73x_it.c main.c Readme.txt
  group Startup
    ../common/str73x_lib/project/EWARM/: 73x_init.s 73x_vect.s
  group STR73x_Library
    ../common/str73x_lib/library/src/: 73x_adc.c 73x_cfg.c 73x_cmu.c 73x_eic.c 73x_gpio.c 73x_lib.c
    ../common/: 73x_lcd.c 73x_lcd.h
