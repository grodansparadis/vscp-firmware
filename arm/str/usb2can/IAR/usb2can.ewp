# IAR project usb2can.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR750 ST STR750
  ICCARM.CCIncludePath2: str75x_lib\inc; USBLibrary\inc; include; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: usb2can.bin
  ILINK.IlinkOutputFile: usb2can.out
  ILINK.IlinkIcfFile: D:\Work\VSCP\USB2CAN\firmware\IAR\linker\STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: 75x_it.c buffers.c commands.c configuration.c i2c_ee.c leds.c lists.c low_level_init.c main.c messages.c
    linker/: STR75x_FLASH.icf
  group library
    str75x_lib/src/: 75x_can.c 75x_cfg.c 75x_eic.c 75x_gpio.c 75x_i2c.c 75x_lib.c 75x_mrcc.c 75x_pwm.c 75x_tb.c 75x_tim.c 75x_uart.c 75x_wdg.c
  group startup
    Startup/: 75x_init.s 75x_vect.s
  group USBApp
    USBApp/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USBLib
    USBLibrary/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
