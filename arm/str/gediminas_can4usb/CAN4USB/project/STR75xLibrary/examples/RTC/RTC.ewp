# IAR project RTC.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STR750 ST STR750
  ICCARM.CCIncludePath2: ; ..\..\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: RTC.out
  ILINK.IlinkIcfFile: ..\..\linker\STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 75x_it.c main.c
  group source
    ../../library/src/: 75x_eic.c 75x_gpio.c 75x_lib.c 75x_mrcc.c 75x_rtc.c 75x_uart.c
  group startup
    ../../startup/: 75x_init.s 75x_vect.s
