<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SMI_Example1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


