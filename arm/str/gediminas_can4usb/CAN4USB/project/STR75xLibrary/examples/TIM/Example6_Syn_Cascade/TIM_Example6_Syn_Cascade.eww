<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TIM_Example6_Syn_Cascade.ewp</path>
  </project>
  <batchBuild/>
</workspace>


