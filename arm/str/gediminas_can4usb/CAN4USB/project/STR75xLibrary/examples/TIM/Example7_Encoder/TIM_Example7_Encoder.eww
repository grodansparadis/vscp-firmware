<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TIM_Example7_Encoder.ewp</path>
  </project>
  <batchBuild/>
</workspace>


