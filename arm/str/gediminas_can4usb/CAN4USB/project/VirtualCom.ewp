# IAR project VirtualCom.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR750 ST STR750
  ICCARM.CCIncludePath2: ; app\; board\; module\; STR75xLibrary\library\inc\; j:\common
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: VirtualCom.hex
  ILINK.IlinkOutputFile: VirtualCom.out
  ILINK.IlinkIcfFile: config\STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RELEASE (ARM)
  as the first configuration, except:
  group (top)
    app/: 75x_conf.h 75x_it.c cd_class.c delay.c delay.h main.c sysTime.h sysTime75x.c vscp_compiler.h vscp_projdefs.h
    ../../../vscp/firmware/common/: vscp_serial.c vscp_serial.h vscp_type.h
  group Modules
    module/: STR75x_USB.c
  group Startup
    app/: 75x_init.s 75x_vect.s
  group STR75x_lib
    ../../../vscp/firmware/arm/str/cantest_str75x_iar/str75x_lib/src/: 75x_can.c
    $EW_DIR$/ARM/examples/ST/STR75x/STR75xLibrary/library/src/: 75x_cfg.c 75x_gpio.c 75x_lib.c 75x_mrcc.c 75x_tim.c 75x_uart.c
    STR75xLibrary/library/src/: 75x_eic.c 75x_tb.c
  group USB
    app/: usb_dev_desc.c
