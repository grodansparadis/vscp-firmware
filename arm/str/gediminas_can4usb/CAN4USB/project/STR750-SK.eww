<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lcd</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>LedBlink</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MassStorage</project>
        <configuration>Debug KS</configuration>
      </member>
      <member>
        <project>VirtualCom</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


