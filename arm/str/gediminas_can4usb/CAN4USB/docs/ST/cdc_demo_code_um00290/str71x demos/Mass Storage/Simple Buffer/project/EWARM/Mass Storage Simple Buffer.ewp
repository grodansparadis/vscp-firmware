# IAR project Mass Storage Simple Buffer.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: STR710 ST STR710
  ICCARM.CCIncludePath2: ..\..\..\..\..\library\inc\; ..\..\..\..\..\stdlib\str71x\include\; ..\..\include\; ..\..\..\common\include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
  group (top)
    ./: 71x_init.s 71x_vect.s
  group Application files
    ../../../Common/source/: 71x_it.c hw_config.c main.c SCSI_data.c usb_desc.c usb_istr.c usb_pwr.c
    ../../source/: memory.c usb_bot.c usb_endp.c usb_prop.c usb_scsi.c
  group library
    ../../../../../library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group stdlib/str71x
    ../../../../../stdlib/str71x/source/: 71x_lib.c apb.c eic.c gpio.c pcu.c rccu.c
