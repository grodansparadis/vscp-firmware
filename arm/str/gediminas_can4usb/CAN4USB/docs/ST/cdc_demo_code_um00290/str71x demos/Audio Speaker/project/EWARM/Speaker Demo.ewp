# IAR project Speaker Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: STR710 ST STR710
  ICCARM.CCIncludePath2: ..\..\include\; ..\..\..\..\library\inc\; ..\..\..\..\stdlib\str71x\include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_ram.xcl
  group (top)
    ./: 71x_init.s 71x_vect.s
  group Application
    ../../source/: 71x_it.c HW_config.c main.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group library
    ../../../../library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group stdlib/str71x
    ../../../../stdlib/str71x/source/: 71x_lib.c apb.c gpio.c pcu.c rccu.c tim.c xti.c
