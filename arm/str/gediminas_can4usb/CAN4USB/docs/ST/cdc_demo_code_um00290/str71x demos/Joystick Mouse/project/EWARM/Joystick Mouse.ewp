# IAR project Joystick Mouse.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: STR711 ST STR711
  ICCARM.CCIncludePath2: ..\..\include\; ..\..\..\..\library\inc\; ..\..\..\..\stdlib\str71x\include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
  group (top)
    ./: 71x_init.s 71x_vect.s
  group Application files
    ../../source/: 71x_it.c HW_config.c main.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group Library
    ../../../../library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group StdLib/str71x
    ../../../../stdlib/str71x/source/: 71x_lib.c apb.c gpio.c pcu.c rccu.c xti.c
