# IAR project VirtualCom.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR750 ST STR750
  ICCARM.CCIncludePath2: ; app\; board\; module\; $EW_DIR$\ARM\examples\ST\STR75x\STR75xLibrary\library\inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: VirtualCom.out
  ILINK.IlinkIcfFile: config\STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: 75x_conf.h 75x_it.c cd_class.c main.c uart.c
  group Modules
    module/: drv_hd44780.c drv_hd44780_l.c STR75x_USB.c
  group Startup
    app/: 75x_init.s 75x_vect.s
  group STR75x_lib
    $EW_DIR$/ARM/examples/ST/STR75x/STR75xLibrary/library/src/: 75x_cfg.c 75x_eic.c 75x_gpio.c 75x_lib.c 75x_mrcc.c 75x_tim.c 75x_uart.c
  group USB
    app/: usb_dev_desc.c
