<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TIM_Example4_Sync_Parellel.ewp</path>
  </project>
  <batchBuild/>
</workspace>


