# IAR project EXTIT.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR750 ST STR750
  ICCARM.CCIncludePath2: ; ..\..\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: EXTIT.out
  ILINK.IlinkIcfFile: ..\..\linker\STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 75x_it.c main.c
  group source
    ../../library/src/: 75x_eic.c 75x_extit.c 75x_gpio.c 75x_lib.c 75x_mrcc.c
  group startup
    ../../startup/: 75x_init.s 75x_vect.s
