<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CAN\CAN.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC\Example1\ADC_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC\Example2\ADC_Example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DMA\Example1\DMA_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EIC\EIC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DMA\Example2\DMA_Example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\GPIO\GPIO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\I2C\I2C.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DMA\Example3\DMA_Example3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EXTIT\EXTIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MRCC\Example1\MRCC_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MRCC\Example2\MRCC_Example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MRCC\Example3\MRCC_Example3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MRCC\Example4\MRCC_Example4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\PWM\Example1\PWM_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\RTC\RTC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\PWM\Example2\PWM_Example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\PWM\Example3\PWM_Example3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SMI\Example1\SMI_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SMI\Example2\SMI_Example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SSP\Example1\SSP_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SSP\Example2\SSP_Example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SSP\Example3\SSP_Example3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SSP\Example4\SSP_Example4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TB\Example1\TB_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TB\Example2\TB_Example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TB\Example3\TB_Example3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example2_PWMI\TIM_Example2_PWMI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example4_Sync_Parallel\TIM_Example4_Sync_Parellel.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example5_DMA\TIM_Example5_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example6_Syn_Cascade\TIM_Example6_Syn_Cascade.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example7_Encoder\TIM_Example7_Encoder.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example1_OC\OCActive_Mode\TIM_OCActive_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example1_OC\OCTiming_Mode\TIM_OCTiming_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example3_OPM\OPM_PWM_Mode\TIM_OPM_PWM_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example3_OPM\OPM_Toggle_Mode\TIM_OPM_Toggle_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example1_OC\PWM_Mode\TIM_PWM_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\Example1_OC\Toggle_Mode\TIM_Toggle_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\Example1\UART_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\Example2\UART_Example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\Example3\UART_Example3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\Example4\UART_Example4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\WDG\WDG.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\Example5\UART_Example5.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\Example6\UART_Example6.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ADC_Example1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ADC_Example2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CAN</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMA_Example1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMA_Example2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMA_Example3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>EIC</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>EXTIT</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>GPIO</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>I2C</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MRCC_Example1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MRCC_Example2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MRCC_Example3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MRCC_Example4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>PWM_Example1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>PWM_Example2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>PWM_Example3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>RTC</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SMI_Example1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SMI_Example2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SSP_Example1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SSP_Example2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SSP_Example3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SSP_Example4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TB_Example1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TB_Example2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TB_Example3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Example2_PWMI</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Example4_Sync_Parellel</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Example5_DMA</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Example6_Syn_Cascade</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Example7_Encoder</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_OCActive_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_OCTiming_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_OPM_PWM_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_OPM_Toggle_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_PWM_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Toggle_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example5</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example6</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>WDG</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


