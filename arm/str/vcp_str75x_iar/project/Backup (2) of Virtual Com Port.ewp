# IAR project Backup (2) of Virtual Com Port.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: STR750 ST STR750
  ICCARM.CCIncludePath2: ..\..\include\; ..\..\..\..\library\inc\; ..\..\..\..\stdlib\str75x\inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
  group (top)
    ./: 75x_init.s 75x_vect.s
  group Application File
    ../../source/: 75x_it.c hw_config.c main.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group library
    ../../../../library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group StdLib/str75x
    ../../../../stdlib/str75x/src/: 75x_cfg.c 75x_eic.c 75x_extit.c 75x_gpio.c 75x_lib.c 75x_mrcc.c 75x_uart.c
