# IAR project cantest.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR730 ST STR730
  ICCARM.CCIncludePath2: str73x_lib\include; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: cantest.srec
  ILINK.IlinkOutputFile: cantest.out
  ILINK.IlinkIcfFile: linker\STR73x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: 73x_conf.h 73x_it.c 73x_lcd.c 73x_lcd.h main.c
  group source
    str73x_lib/source/: 73x_adc.c 73x_can.c 73x_cfg.c 73x_cmu.c 73x_eic.c 73x_gpio.c 73x_lib.c 73x_prccu.c 73x_rtc.c
  group startup
    Startup/: 73x_init.s 73x_vect.s
