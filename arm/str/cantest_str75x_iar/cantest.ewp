# IAR project cantest.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR750 ST STR750
  ICCARM.CCIncludePath2: str75x_lib\inc; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: cantest.hex
  ILINK.IlinkOutputFile: cantest.out
  ILINK.IlinkIcfFile: linker\STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: 75x_conf.h 75x_it.c main.c
  group source
    str75x_lib/src/: 75x_can.c 75x_eic.c 75x_gpio.c 75x_lib.c 75x_mrcc.c
  group startup
    Startup/: 75x_init.s 75x_vect.s
