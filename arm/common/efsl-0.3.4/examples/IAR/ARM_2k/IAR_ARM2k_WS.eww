<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAR_EFSL.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IAR_LPC214x.ewp</path>
  </project>
  <batchBuild/>
</workspace>


