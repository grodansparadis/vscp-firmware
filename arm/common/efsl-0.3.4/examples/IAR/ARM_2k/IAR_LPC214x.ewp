# IAR project IAR_LPC214x.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: LPC2148 Philips LPC2148
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\src\include; ..\..\..\src\base\include; ..\..\..\src\fs\vfat\include; ..\..\..\src\protocols\sdcard_spi\include; ..\..\..\src\hwdrivers\arm2k_spi\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\dev\tekmar\Software\Projects\LPC2148_FF_DEMO\LPC2148_FF_DEMO\settings\LPC2148_RAM.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
  group (top)
    ./: demo.c lpc2xxx_cstartup.s79
  group doc
    ./: readme.txt
  group Libs/debug
    Debug/Exe/: IAR_EFSL.r79
  group Libs/release
    Release/Exe/: IAR_EFSL.r79
