# IAR project IAR_EFSL.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\src\include; ..\..\..\src\base\include; ..\..\..\src\fs\vfat\include; ..\..\..\src\protocols\sdcard_spi\include; ..\..\..\src\hwdrivers\arm2k_spi\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group base
    ../../../src/base/: debug.c disc.c efs.c extract.c interface.c ioman.c partition.c plibc.c sextract.c
  group doc
    ./: readme.txt
  group hardware
    ../../../src/hwdrivers/arm2k_spi/: arm2k_pll.c arm2k_rtc.c arm2k_ssp.c arm2k_uart.c
  group sd
    ../../../src/protocols/sdcard_spi/: sd.c
  group vfat
    ../../../src/fs/vfat/: dir.c fat.c file.c fs.c ls.c mkfs.c time.c ui.c
