# IAR project kelvin_iar_debug_258.ewp, settings and files
configuration Debug (PIC18, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\CLIB\cl18os.h
  ICCPIC18.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkIncludePath: 0
configuration Release (PIC18)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICCPIC18.CCDefines: NDEBUG
  group (top)
    ./: main.c main.h smartec.c smartec.h version.h vscp_compiler.h vscp_projdefs.h
